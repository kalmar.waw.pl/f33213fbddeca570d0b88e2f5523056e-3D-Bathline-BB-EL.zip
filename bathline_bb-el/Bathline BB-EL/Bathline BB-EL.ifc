Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2018-01-09T14:05:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.0.490.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jan 09 14:05:54 2018 * Host: ZZ010968 * Database: C:\Users\YARINM~1\AppData\Local\Temp\{BA2D8E52-E665-4501-9808-B7E0CD4A7B24}\ifc * Database version: 5507 * Database creation date: Tue Jan 09 14:05:53 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jan 09 14:05:53 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jan 09 14:05:53 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: R:\CPR\Operations\Projecten\Vasco\Modellen\Prio 4\Bathline\Bathline BB-EL.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Identity Data - Type Name: Level 1; Building Story: yes; Name: Level 1; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: BB-EL Ventielset, BB-EL Ventielset:BB-EL Ventielset:25188
In: Level 1
Type - Identity Data - OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: BB-EL Ventielset
Type - Other - Category: Mechanical Equipment; Family Name: BB-EL Ventielset
Pset_BuildingElementProxyCommon - Reference: BB-EL Ventielset
Constraints - Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1; Offset: 122 mm
Dimensions - Area: 0.0157182 m2; Volume: 0.000286814 m3
Identity Data - Mark: 13
Other - Family: BB-EL Ventielset: BB-EL Ventielset; Family and Type: BB-EL Ventielset: BB-EL Ventielset; Type: BB-EL Ventielset: BB-EL Ventielset; Type Id: BB-EL Ventielset: BB-EL Ventielset
Phasing - Phase Created: New Construction

# IfcBuildingElementProxy: BB-EL_600_1802, Bathline BB-EL:BB-EL_600_1802:25187
In: Level 1
Type - Material: Traffic White
Type - Dimensions - NLRS_C_breedte: 600 mm; NLRS_C_breedte_01: 532 mm; NLRS_C_dikte: 34 mm; NLRS_C_hoogte: 1802 mm; NLRS_C_hoogte_01: 345 mm; NLRS_C_hoogte_02: 268 mm; NLRS_C_hoogte_03: 268 mm; NLRS_C_hoogte_04: 268 mm; NLRS_C_hoogte_05: 93 mm; NLRS_C_hoogte_06: 93 mm; Offset: 1962 mm; Offset 01: 140 mm; Offset 02: 122 mm
Type - Energy Analysis - NLRS_M_afgifte_verwarming: 13454.9
Type - General - NLRS_E_c01_diameter: 30 mm; NLRS_E_c02_diameter: 30 mm; NLRS_P_c01_volumestroom: 0 m3/s; NLRS_P_c02_volumestroom: 0 m3/s
Type - Identity Data - Description: Bathline BB-EL; Manufacturer: Vasco; Model: Bathline; OmniClass Number: 23.75.00.00; OmniClass Title: Climate Control (HVAC); Type Name: BB-EL_600_1802; URL: https://vasco.eu/nl-nl/radiatoren/elektrische-radiatoren/bathline--bb-el
Type - Materials and Finishes - Disclaimer: Kleuren kunnen afwijken van de op het scherm getoonde kleuren, voor de exacte kleuren gelieve de Vasco kleurenkaart te gebruiken; Kleur naam: Traffic White; NLRS_C_materiaal: Traffic White; RAL/RGB kleur: 9016; Wél verkrijgbaar: Traffic White
Type - Mechanical - con 1_hoek hor: 90 deg; con 1_hoek ver: 0 deg; con 1_pos x: 583 mm; con 1_pos y: 16 mm; con 1_pos z: 115 mm; con 2_hoek hor: 90 deg; con 2_hoek ver: 0 deg; con 2_pos x: 51 mm; con 2_pos y: 16 mm; con 2_pos z: 115 mm; vermogen: 13454.9
Type - Mechanical - Flow - CDC_M_aanvoertemperatuur: 75 kg/K/s3; CDC_M_retourtemperatuur: 65 kg/K/s3; CDC_M_ruimte_temperatuur: 20 kg/K/s3; delta_T: 10; deltat_factor: 50
Type - Other - Category: Mechanical Equipment; Family Name: Bathline BB-EL; NLRS_C_aantal_01: 9; NLRS_C_aantal_02: 7; NLRS_C_aantal_03: 7; NLRS_C_aantal_04: 7; NLRS_C_aantal_05: 7; NLRS_C_code_ETIM: EC011023; NLRS_C_code_ETIM_url: https://prod.etim-international.com/Class/Details?classId=EC011023&classVersion=4; Positie 1: Ventielset Comfort Collection - Sluitnippel: Ventielset Comfort Collection - Sluitnippel; Positie 4: Ventielset Comfort Collection - Sluitnippel: Ventielset Comfort Collection - Sluitnippel; Positie 5: Ventielset - Ontluchter: Ventielset - Ontluchter; Positie 8: BB-EL Ventielset: BB-EL Ventielset
Type - Text - NLRS_C_gewicht: 30.9
Type - Visibility - Visible 04: yes; Visible 05: yes
Pset_BuildingElementProxyCommon - Reference: BB-EL_600_1802
Pset_ManufacturerTypeInformation - Manufacturer: Vasco
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.16287 m2; Volume: 0.0367608 m3
Identity Data - Mark: 12
Other - Family: Bathline BB-EL: BB-EL_600_1802; Family and Type: Bathline BB-EL: BB-EL_600_1802; Type: Bathline BB-EL: BB-EL_600_1802; Type Id: Bathline BB-EL: BB-EL_600_1802
Phasing - Phase Created: New Construction
